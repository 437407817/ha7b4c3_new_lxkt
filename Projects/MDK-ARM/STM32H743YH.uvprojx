# Keil uVision project STM32H743YH.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743YH +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config_sha_x.h>,USE_HAL_DRIVER,STM32H743xx,__DCACHE_PRESENT=1,
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Middlewares\Third_Party\SeggerRTT;..\..\User;..\..\Core\Inc;..\..\Drivers\STM32H7_Driver;..\..\Middlewares\Wmap_lib;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middlewares\Third_Party\letter-shell\src;..\..\Middlewares\Third_Party\letter-shell\extensions\log;..\..\Middlewares\Third_Party\letter-shell\demo\stm32-freertos;..\..\Middlewares\Third_Party\easylogger\inc;..\..\Middlewares\Third_Party\LVGL\GUI;..\..\Middlewares\Third_Party\LVGL\GUI\lvgl;..\..\Middlewares\Third_Party\LVGL\GUI\lvgl\src;..\..\Middlewares\Third_Party\LVGL\GUI\lvgl\examples\porting;..\..\Middlewares\Third_Party\LVGL\GUI_APP\demos;..\..\Middlewares\Third_Party\LVGL\GUI_APP\demos\stress;..\..\Middlewares\Third_Party\LVGL\lv_wmap_app;..\..\Middlewares\Third_Party_user\freertosutil;..\..\Middlewares\Third_Party\sfud\inc;..\..\Middlewares\Third_Party\LVGL\GUI_APP\ui;..\..\User_pro;..\..\Middlewares\Third_Party\SystemView\Config;..\..\Middlewares\Third_Party\SystemView\SEGGER;..\..\Middlewares\Third_Party\SystemView\SYSVIEW;..\..\Middlewares\Third_Party\SeggerRTT\Config;..\..\Middlewares\Third_Party\SystemView\Sample\FreeRTOSV10;..\..\Middlewares\Third_Party\mbedtls-3.6\include;..\..\Middlewares\Third_Party\mbedtls-3.6\configs;..\..\Middlewares\Third_Party\mbedtls-3.6\library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Start
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../Core/Inc/: stm32h7xx_hal_conf.h stm32_USER_conf.h user_config.h user_test_config.h stm32_FH_xxx.h stm32_FH_xxx_hal.h
  group STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_msp.c stm32h7xx_hal_msp_template.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_timebase_rtc_alarm_template.c stm32h7xx_hal_timebase_rtc_wakeup_template.c stm32h7xx_hal_timebase_tim_template.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group Third_Party/SeggerRTT
    ../../Middlewares/Third_Party/SeggerRTT/: SEGGER_dao.c SEGGER_OutInterface.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_TOOLKIT.c
  group Third_Party/SystemView
    ../../Middlewares/Third_Party/SystemView/Config/: Global.h SEGGER_SYSVIEW_Conf.h
    ../../Middlewares/Third_Party/SystemView/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h
    ../../Middlewares/Third_Party/SystemView/Sample/FreeRTOSV10/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../../Middlewares/Third_Party/SystemView/SEGGER/: SEGGER.h
    ../../Middlewares/Third_Party/SystemView/SYSVIEW/: SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group Third_Party/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Third_Party/FreeRTOS/TASK
    ../../Middlewares/Third_Party/FreeRTOS/Source/: freerotspro.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/task/: user_LVGLTask.c user_SystemTask.c user_Task_1.c user_TestTask.c rtos_ProBtnTask.c rtos_comTask.c
  group MAIN
    ../../User/: main.c main.h stm32h7xx_it.h stm32h7xx_it.c
    ../../Middlewares/Wmap_lib/sys/: sys_init_all.c
    ../../User_pro/global/: GV_enum.c GV_variable.c
  group SFUD
    ../../Middlewares/Third_Party/sfud/src/: sfud.c sfud_sfdp.c
    ../../Middlewares/Third_Party/sfud/port/: sfud_port.c
  group BSP_COMMON_DRIVER
    ../../User/buffer/: p_data_queue.c p_data_queue_outer.c que.c queue2.c queue3.c user_buffers.c
    ../../User/usart/: bsp_usart_callback.c bsp_com_uart.c bsp_usart_dma.c bsp_usart_common_dma.c
    ../../User/dma/: bsp_dma.c
    ../../User/i2c/: factory_iic.c
    ../../User/i2c/hard_i2c/: bsp_i2c_ee.c
    ../../User/i2c/soft_i2c/: bsp_soft_i2c_ee.c bsp_soft_i2c_gpio.c
    ../../User/sdram/: bsp_sdram_dma.c
    ../../User/mpu/: bsp_mpu.c
    ../../User/fonts/: font24.c
    ../../User/spi/: bsp_spi.c bsp_spi_flash.c bsp_qspi_a.c bsp_qspi.c
    ../../User/io/: bsp_io_input.c bsp_io_output.c
    ../../User_pro/sensor/: DS1302.c
    ../../User/power/: bsp_power.c
  group BSP_H743_DRIVER
    ../../Drivers/STM32H7_Driver/usart/: bsp_usart.c bsp_usart_shell.c
    ../../Drivers/STM32H7_Driver/i2c/hard_i2c/: bsp_iic.c
    ../../Drivers/STM32H7_Driver/sdram/: bsp_sdram.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/touch/: bsp_i2c_touch.c gt9xx.c touch_drv.c
    ../../User/flash/: bsp_qspi_flash.c
  group Application/Modules/Business
    ../../Middlewares/Wmap_lib/Modules/: common.h mmc.h mmc.c business.c busi_test.c
  group WMAP_lib/sys
    ../../Middlewares/Wmap_lib/sys/: sysio.h bsp_systime.c sys_dwt.c sys_interrupt.c systick.c
  group WMAP_lib/StateMechine
    ../../Middlewares/Wmap_lib/StateMechine/: TaskFun.c TaskFun_Outer.c TaskSema.c TaskSemaFun_Outer.c TaskWorkHandle.c
  group WMAP_lib/convert
    ../../Middlewares/Wmap_lib/DataConvert/: data_compare.c data_convert.c data_find.c data_random.c data_verification.c w_string.c data_set.c cvt_time.c
    ../../Middlewares/Wmap_lib/DataCache/: data_heap.c data_stack.c
  group TASK
    ../../Middlewares/Wmap_lib/TaskTest/: Task_mockheap_stack.c Task_check.c Task_StressTest.c
    ../../Middlewares/Third_Party_user/freertosutil/hook/: hook_mem.c
    ../../Middlewares/Third_Party_user/freertosutil/rtosprintf/: frtos_printf.c
    ../../Middlewares/Wmap_lib/HAL/: hal_ext_uart.c
  group TEST
    ../../User/test/: bsp_all_test.c bsp_usart_test.c bsp_iic_test.c bsp_sdram_test.c bsp_lcd_test.c bsp_qspi_flash_test.c bsp_spi_test.c bsp_other_test.c
    ../../User_pro/sensor/: bsp_test_DS1302.c
  group WMAP_lib/EastLogger
    ../../Middlewares/Third_Party/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../../Middlewares/Third_Party/easylogger/port/: elog_port.c
  group WMAP_lib/letter_shell
    ../../Middlewares/Third_Party/letter-shell/: letter_shell_noos_cmd.c letter_shell_rtos_cmd.c
    ../../Middlewares/Third_Party/letter-shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_print.c
    ../../Middlewares/Third_Party/letter-shell/demo/stm32-freertos/: shell_port.c
    ../../Middlewares/Third_Party/letter-shell/extensions/log/: log.c
  group lvgl/example/porting
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../../Middlewares/Third_Party/LVGL/GUI/: lvgl_port.c
    ../../User/timer/: btim.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/: lv_init.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/: lv_conf.h lv_version.h lvgl.h lvgl_private.h
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/fonts/: noto_sans_sc_16.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/components/: ui_translate.c
  group lvgl/src/core
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/display/: lv_display.c
  group lvgl/src/draw
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
  group lvgl/src/driver
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/drivers/evdev/: lv_evdev.c
  group lvgl/src/font
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/indev
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group lvgl/src/layouts
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/layouts/: lv_layout.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/src/libs
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/bmp/: lv_bmp.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/gif/: lv_gif.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/libpng/: lv_libpng.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/lz4/: lz4.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/rle/: lv_rle.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group lvgl/src/misc
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group lvgl/src/osal
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os.c lv_os_none.c lv_rtthread.c
  group lvgl/src/others
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/monkey/: lv_monkey.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/observer/: lv_observer.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/translation/: lv_translation.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group lvgl/src/others_xml
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group lvgl/src/stdlib
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/themes
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/themes/: lv_theme.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/themes/simple/: lv_theme_simple.c
  group lvgl/src/tick
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/tick/: lv_tick.c
  group lvgl/src/widgets
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/button/: lv_button.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/image/: lv_image.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/scale/: lv_scale.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
  group LVGL/GUI_APP_example
    ../../Middlewares/Third_Party/LVGL/GUI/lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c lv_example_get_started_4.c
  group LVGL/GUI_APP
    ../../Middlewares/Third_Party/LVGL/lv_wmap_app/lv_app_base/: lv_app_base.c lv_w_demo.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/: ui.c ui_helpers.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/screens/: ui_Screen1.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/images/: ui_img_arrow_png.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/fonts/: ui_font_badge2.c ui_font_exclamation.c ui_font_H1_bold.c ui_font_H2_bold.c ui_font_H3_bold.c ui_font_icon.c ui_font_Min.c ui_font_P1_bold.c ui_font_P1_medium.c ui_font_P2_medium.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/components/: ui_comp_hook.c
  group LVGL/GUI_APP_user
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/screens/: ui_S_page02.c ui_S_page01.c status_bar.c
    ../../Middlewares/Third_Party/LVGL/GUI_APP/ui/: lvgl_user_inc.h
  group mbedtls-3.6
    ../../Middlewares/Third_Party/mbedtls-3.6/configs/: mbedtls_config_sha_x.h
    ../../Middlewares/Third_Party/mbedtls-3.6/library/: aes.c chacha20.c chachapoly.c cipher.c cipher_wrap.c constant_time.c gcm.c platform.c platform_util.c poly1305.c threading.c
  group pro/commu
    ../../User_pro/usart/: bsp_usart_com485.c bsp_usart_common_com485.c
    ../../User_pro/pro_com/: usart485_common_verify.c usart_485_232_send.c usart485verify.c
    ../../User_pro/middle_controller/: user_business.c
    ../../User_pro/global/: GV_variable.c GV_enum.c
    ../../User_pro/middle_business/: usart_485_dataGet.c usart_485_dataMethod.c usart_485_sendMethod.c
  group screen
    ../../User_pro/screen/: ScreenDataDis.c ScreenDS1302.c ScreenSendFun.c DW_com_send.c ScreenErrorDataSendFun.c ScreenNomalDataSendFun.c
  group project_API
    ../../User_pro/project_API/: hardware_interface_api.h
  group service
    ../../User_pro/service/: Workled.c Pwr_StateMachine.c UI_StateMachine.c StandbyMechineFun.c EepromFun.c PowerDownFun.c bsp_usart_sd.c StartMechineFun.c StopMechineFun.c ActiveMechineFun.c CapacityFun.c DisposeDataFun.c
    ../../User_pro/communication/: SD_485DataFun.c
  group controller
    ../../User_pro/controller/: StateFun.c DisStateFun.c
  group crypt
    ../../User/crypt/: bsp_encode.c chipID_dis.c crypt_aes.c crypt_aes_test.c
